# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\FWLIB\src;..\SYSTEM;..\Hardware;..\Hardware\MPU6050;..\Algorithm;..\USER;..\Hardware\Vision;..\Hardware\MPU6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/: delay.c delay.h sys.c sys.h usart.c usart.h
    ../Hardware/: TimerX.c TimerX.h exti.c exti.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dma.c
  group README
    ../: readme.txt
  group Hardware
    ../Hardware/: headfile.h FONT.H led.c led.h myiic.c myiic.h Key.c Key.h Motor.c Motor.h encoder.c encoder.h InfraredTracking.c InfraredTracking.h HX711.c HX711.h lcd_init.c lcd_init.h lcdfont.h lcd.c lcd.h Menu_TFT.c Menu_TFT.h
  group Positioning
    ../Hardware/MPU6050/: mpu6050.c mpu6050.h
    ../Hardware/MPU6050/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group Algorithm
    ../Algorithm/: PID.c PID.h MotionControl.c MotionControl.h Fsm.c Fsm.h Task_basic.c Task_basic.h
  group Vision
    ../Hardware/Vision/: bsp_usart.c bsp_usart.h k210_use.c openmv_use.c cam_use.h
